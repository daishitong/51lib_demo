# Keil uVision project Ultrasound_Serial.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Ultrasound_Serial +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\51lib\inc
  group Source Group 1
    ./: STARTUP.A51 main.c
  group 51lib
    ../51lib/inc/: 51lib.h
    ../51lib/: 51lib.LIB
